# IAR project msc_udisk.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E113xB GD GD32E113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32E11X
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32E11x_Firmware_Library\\CMSIS\GD\GD32E11x\Include; ..\..\..\..\GD32E11x_Firmware_Library\GD32E11x_usbfs_library\device\class\msc\Include; ..\..\..\..\GD32E11x_Firmware_Library\GD32E11x_usbfs_library\device\core\Include; ..\..\..\..\GD32E11x_Firmware_Library\GD32E11x_usbfs_library\driver\Include; ..\..\..\..\GD32E11x_Firmware_Library\GD32E11x_usbfs_library\ustd\class\msc; ..\..\..\..\GD32E11x_Firmware_Library\GD32E11x_usbfs_library\ustd\common; ..\..\..\..\GD32E11x_Firmware_Library\\GD32E11x_standard_peripheral\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  ILINK.IlinkOutputFile: msc_udisk.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c flash_msd.c gd32e11x_hw.c gd32e11x_it.c usbd_storage_msd.c
  group CMSIS
    ../../../../GD32E11x_Firmware_Library/CMSIS/GD/GD32E11x/Source/: system_gd32e11x.c
  group Doc
    ../: readme.txt
  group GD32E11x_EVAL
    ../../../Utilities/: gd32e113c_start.c
  group GD32E11x_StdPeriph
    ../../../../GD32E11x_Firmware_Library/GD32E11x_standard_peripheral/Source/: gd32e11x_dma.c gd32e11x_exti.c gd32e11x_fmc.c gd32e11x_gpio.c gd32e11x_misc.c gd32e11x_pmu.c gd32e11x_rcu.c gd32e11x_timer.c gd32e11x_usart.c
  group Startup
    ../../../../GD32E11x_Firmware_Library/CMSIS/GD/GD32E11x/Source/IAR/: startup_gd32e11x.s
  group USB_Class
    ../../../../GD32E11x_Firmware_Library/GD32E11x_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group USB_Device
    ../../../../GD32E11x_Firmware_Library/GD32E11x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../GD32E11x_Firmware_Library/GD32E11x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
