# IAR project GD32E113V_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E113xB GD GD32E113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E11X
  ICCARM.CCIncludePath2: ..\..\..\..\GD32E11x_Firmware_Library\GD32E11x_standard_peripheral\Include; ..\..\..\..\GD32E11x_Firmware_Library\CMSIS\GD\GD32E11x\Include; ..; ..\..\..\Utilities; ..\Soft_Drive; ..\..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32e11x_it.c main.c systick.c
    ../Soft_Drive/: rtc.c
  group CMSIS
    ../../../../GD32E11x_Firmware_Library/CMSIS/GD/GD32E11x/Source/: system_gd32e11x.c
  group Doc
    ../: readme.txt
  group GD32E11x_EVAL
    ../../../Utilities/: gd32e113v_eval.c gd32e113v_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group GD32E11x_Peripherals
    ../../../../GD32E11x_Firmware_Library/GD32E11x_standard_peripheral/Source/: gd32e11x_adc.c gd32e11x_bkp.c gd32e11x_crc.c gd32e11x_ctc.c gd32e11x_dac.c gd32e11x_dbg.c gd32e11x_dma.c gd32e11x_exmc.c gd32e11x_exti.c gd32e11x_fmc.c gd32e11x_fwdgt.c gd32e11x_gpio.c gd32e11x_i2c.c gd32e11x_misc.c gd32e11x_pmu.c gd32e11x_rcu.c gd32e11x_rtc.c gd32e11x_spi.c gd32e11x_timer.c gd32e11x_usart.c gd32e11x_wwdgt.c
  group Startup
    ../../../../GD32E11x_Firmware_Library/CMSIS/GD/GD32E11x/Source/IAR/: startup_gd32e11x.s
